# Repository hulkco/Granabot

## KiCad design Hardware/OSHPark/001.kicad_pcb

Board: 2 copper layers, 73.1 x 87.8 mm, 28 parts (15 on the bottom side), 18 nets.

Parts:
C1, C2: 4.7uF; C_1206_HandSoldering
C3: 22nF; C_1206_HandSoldering
CAP1: CAPSENSE_CIRCLE; CAPSENSE-CIRCLE2-D10MM
D1: MBRA140; D_SOD-123
D2: ON; LED_1206_HandSoldering
J1: CONN_01X02; Molex_PicoBlade_53261-0271_02x1.25mm_Angled
J2: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm_SMD_Pin1Left
J3: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm_SMD_Pin1Right
J4: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm_SMD
J5: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm_SMD_Pin1Left
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8: WS2812B
R1: 1k; R_1206_HandSoldering
R2: 1M Ohms; R_1206_HandSoldering
U1: LM340MP-5.0/NOPB; SOT-223-3Lead_TabPin2
U2: ATTINY85-20SU; SOIC-8_3.9x4.9mm_Pitch1.27mm
svg2mod1: G***1; logo_letra_Cu
svg2mod2: G***2; logo_letra_Mask
svg2mod3: G***3; logo_letra_Cu
svg2mod4: G***4; logo_letra_Mask
svg2mod4#2: G***4; hormiga con borde

Connections:
3-A3: J2.3, U2.2
4-A2: LED1.2, U2.3
+5V: C2.1, C3.1, J2.1, J3.1, J4.2, LED1.3, LED2.3, LED3.3, LED4.3, LED5.3, LED6.3, LED7.3, LED8.3, R1.1, U1.3, U2.8
GND: C1.2, C2.2, C3.2, D2.1, J1.2, J2.2, J3.2, J4.6, J5.1, LED1.1, LED2.1, LED3.1, LED4.1, LED5.1, LED6.1, LED7.1, LED8.1, U1.2, U2.4
MISO-1-PWM: CAP1.1, J4.1, R2.2, U2.6
MOSI-0-PWM: J4.4, R2.1, U2.5
unnamed: D2.2, R1.2
unnamed: LED1.4, LED2.2
unnamed: LED2.4, LED3.2
unnamed: LED3.4, LED4.2
unnamed: LED4.4, LED5.2
unnamed: LED5.4, LED6.2
unnamed: LED6.4, LED7.2
unnamed: LED7.4, LED8.2
RESET: J4.5, U2.1
SCK-2-A1: J3.3, J4.3, U2.7
VBAT: D1.2, J1.1
VCC: C1.1, D1.1, J5.2, U1.1

## Commit log

2018-02-19 Auto stash before merge of "master" and "origin/master"
2018-02-19 Generated Gerbers Files
2018-02-20 Esquematico
2018-02-20 Update Capacitors Value en Voltage Regulator
